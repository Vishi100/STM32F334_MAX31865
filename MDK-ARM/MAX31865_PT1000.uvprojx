# Keil uVision project MAX31865_PT1000.uvprojx, settings and files
target MAX31865_PT1000 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F334R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: MAX31865_PT1000
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F334x8
  c misc: --C99
  c include: ../Inc;           ../Drivers/STM32F3xx_HAL_Driver/Inc;           ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;           ../Drivers/CMSIS/Include;           ../Drivers/CMSIS/Device/ST/STM32F3xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f3xx_hal_msp.c main.c stm32f3xx_it.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_tim_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal.c stm32f3xx_hal_pwr.c stm32f3xx_hal_flash.c stm32f3xx_hal_rcc.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
software components: CMSIS:CORE 4.1.0
